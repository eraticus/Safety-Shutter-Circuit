# Repository eraticus/Safety-Shutter-Circuit

File README.md:

# Safety-Shutter-Circuit
Circuit to close shutter if light levels get too high.
The project is separated into three components:
a) Sensors: photodiode amplifier circuit with comparator. Comparator goes low if light too high.
b) ADC: Can be connected with up to four sensor boards. ADC converts light level to digital value. Communication with Shutter Control board via SPI over differential pairs. Also, sensor comparator values ANDed. If a sensors comparator goes low, then a separate low signal sent to shutter control.
c) Shutter Control: Shutter control has multiple subsystems
  1) If a low signal is received from the ADC, a latch is set which controls the state of the shutter.
  2) The light levels are monitored, via the ADC boards, and if the light level approaches the threshold, the shutter is closed.
  3) Communication to LANTRONIX via RS-232 driver connected to RX/TX of microcontroller.

## EAGLE design Shutter.brd

Parts:
ADC1, ADC2: M08; OSTVN08
ADC1_FAULT, ADC2_FAULT: M03; OSTVN03
C1, C2, C3, C4, C16, C18: 1u; CAP_CER_TDK_FK28_5MM
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C19: 100n; 0805_B
C17: 10u; CAP_POL_8_3.5
CO[: 100n; 0805_B
D1, D2: AM26C31; SOIC_16_NARROW
D3: 1N4004; DO41-10
DEWAR_SWITCH: M02; OSTVN02
IC3: MAX3222; DIL18
IC4: 74AC00D; SO14
J1: ATMEL_PROGRAMMER_HEADERTH; ATMEL_PROGRAMMER_HEADER
J2: M06NO_SILK_FEMALE_PTH; 1X06_NO_SILK
MC7808: 7808T; TO220H
MC7812: 7812TV; TO220V
OPEN_CLOSE_TOGGLE: M03; OSTVN03
POWER: M02; OSTVN02
R1, R4, R5, R6, R7: 10K; 0805
R2, R3: 100; 0805
R8: 1.6K; 0805
SHUTTER: M02; OSTVN02
SHUTTER_CLOSED_INDICATOR: M02; OSTVN02
SHUTTER_OPEN_INDICATOR: M02; OSTVN02
SHUTTER_SWITCH: M02; OSTVN02
T1: TIP131; TO220
U1: VOLTAGE_REGULATOR_LDOMCP1702_TO-92; TO-92
U$1: ATMEGA_32828PDIP; DIP-28
U$2: RESONATOR; CSTCE
U$3: TACTILE; CB315FP
U$4: MO3; OSTVN03
U$5, U$6: LTC1485DIP; DIP-8
U$7: DPDTA_DP; A_DP_STRAIGHT_BRACKET
V1: POWER_JACK; PJ-102AH

Connections:
5V: C5.2, C6.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.P$1 (1), CO[.2, D1.16 (VCC), D2.16 (VCC), IC3.17 (VCC), IC3.18 (SHDN/), IC4.14 (VCC), J1.2 (+5), POWER.1, R1.1, R4.2, R5.2, R6.1, R7.2, U1.3 (VOUT), U$1.7 (VCC), U$1.20 (AVCC), U$5.8 (5V), U$6.8 (5V); also elsewhere on the board
8V: ADC1_FAULT.1, ADC2_FAULT.1, C3.P$1 (1), C4.P$1 (1), MC7808.3 (VO), U1.2 (VIN)
12V: C1.P$1 (1), C2.P$1 (1), MC7808.1 (VI), MC7812.3 (VO)
24V: C17.+, C18.P$1 (1), D3.C, MC7812.1 (VI), SHUTTER.1, V1.1 (PWR)
CLOSE_PIN: U$1.14 (PB0(ICP)); also elsewhere on the board
CS+1: ADC1.7, D1.10 (Y)
CS+2: ADC2.7, D2.10 (Y)
CS-1: ADC1.8, D1.11 (Z)
CS-2: ADC2.8, D2.11 (Z)
DEWAR_DIFF_ENABLE: U$1.12 (PD6(AIN0)), U$5.2 (!RE!)
DEWAR_FAULT: ADC1_FAULT.3, DEWAR_SWITCH.1, U$1.5 (PD3(INT1))
DEWAR_FAULT_TRIGGER: DEWAR_SWITCH.2; also elsewhere on the board
DTR: C19.2, J2.6
ENABLE1: D1.12 (!G!)
ENABLE2: D2.12 (!G!)
FTDI_RX: J2.5, U$7.6 (U1)
FTDI_TX: J2.4, U$7.3 (U)
GND: ADC1_FAULT.2, ADC2_FAULT.2, C1.P$2 (2), C2.P$2 (2), C3.P$2 (2), C4.P$2 (2), C5.1, C6.1, C7.1, C8.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.P$2 (2), C17.-, C18.P$2 (2), CO[.1, D1.4 (G), D1.7 (A), D1.8 (GND), D2.4 (G), D2.8 (GND), IC3.1 (EN/), IC3.9 (R2IN), IC3.11 (T2IN), IC3.16 (GND), IC4.7 (GND), J1.6 (GND), J2.1, MC7808.2 (GND), MC7812.2 (GND), OPEN_CLOSE_TOGGLE.2, POWER.2, SHUTTER_CLOSED_INDICATOR.2, SHUTTER_OPEN_INDICATOR.2, T1.3 (E), U1.1 (GND), U$1.8 (GND), U$1.22 (GND), U$2.2, U$3.3 (B), U$3.4 (B), U$4.1, U$5.3 (DE), U$5.4 (DI), U$5.5 (GND), U$6.3 (DE), U$6.4 (DI), U$6.5 (GND), V1.2 (GND); also elsewhere on the board
MAX_RX: IC3.13 (R1OUT), U$7.4 (D1)
MAX_TX: IC3.12 (T1IN), U$7.1 (D)
MISO: J1.1 (MISO), U$1.18 (PB4(MISO)), U$5.1 (RO), U$6.1 (RO)
MISO+1: ADC1.1, R2.2, U$5.6 (A)
MISO+2: ADC2.1, R3.2, U$6.6 (A)
MISO-1: ADC1.2, R2.1, U$5.7 (B)
MISO-2: ADC2.2, R3.1, U$6.7 (B)
MOSI: D1.15 (A), D2.15 (A), J1.4 (MOSI), U$1.17 (PB3(MOSI/OC2))
MOSI+1: ADC1.3, D1.14 (Y)
MOSI+2: ADC2.3, D2.14 (Y)
MOSI-1: ADC1.4, D1.13 (Z)
MOSI-2: ADC2.4, D2.13 (Z)
unnamed: U$1.9 (PB6(XTAL1/TOSC1)), U$2.1
unnamed: U$1.10 (PB7(XTAL2/TOSC2)), U$2.3
unnamed: C7.2, IC3.3 (V+)
unnamed: C8.2, IC3.7 (V-)
unnamed: C9.1, IC3.2 (C1+)
unnamed: C10.1, IC3.5 (C2+)
unnamed: C9.2, IC3.4 (C1-)
unnamed: C10.2, IC3.6 (C2-)
unnamed: D3.A, SHUTTER.2, T1.2 (C)
unnamed: IC4.9 (I0), R6.2
unnamed: IC4.13 (I1), R7.1
unnamed: IC4.10 (I1), IC4.11 (O)
unnamed: IC4.8 (O), IC4.12 (I0)
unnamed: R8.1, T1.1 (B)
OPEN_PIN: U$1.13 (PD7(AIN1)); also elsewhere on the board
RESET_CLOSE_SHUTTER: IC4.1 (I0), OPEN_CLOSE_TOGGLE.1, R4.1; also elsewhere on the board
RST: C19.1, J1.5 (!RST!), R1.2, U$1.1 (PC6(/RESET)), U$3.1 (A), U$3.2 (A)
RX: IC3.14 (R1IN), U$4.2
RXD: U$1.2 (PD0(RXD)), U$7.5 (C1)
SCK: D1.1 (A), D2.1 (A), J1.3 (SCK), U$1.19 (PB5(SCK))
SCK+1: ADC1.5, D1.2 (Y)
SCK+2: ADC2.5, D2.2 (Y)
SCK-1: ADC1.6, D1.3 (Z)
SCK-2: ADC2.6, D2.3 (Z)
SET_OPEN_SHUTTER: IC4.5 (I1), OPEN_CLOSE_TOGGLE.3, R5.1; also elsewhere on the board
SHUTTER_CLOSED_LATCH: IC4.3 (O), IC4.4 (I0), SHUTTER_CLOSED_INDICATOR.1, U$1.4 (PD2(INT0))
SHUTTER_DIFF_ENABLE: U$1.11 (PD5(T1)), U$6.2 (!RE!)
SHUTTER_FAULT: ADC2_FAULT.3, SHUTTER_SWITCH.1
SHUTTER_FAULT_TRIGGER: SHUTTER_SWITCH.2; also elsewhere on the board
SHUTTER_OPEN_LATCH: IC4.2 (I1), IC4.6 (O), R8.2, SHUTTER_OPEN_INDICATOR.1
SS: D1.9 (A), D2.9 (A), U$1.16 (PB2(SS/OC1B))
SW: V1.3 (SW)
TX: IC3.15 (T1OUT), U$4.3
TXD: U$1.3 (PD1(TXD)), U$7.2 (C)

Notes on the sheet:
Regulated Voltage Sources
Put reference here? 4.096?
routed through comm switch
Goes to diff receivers
Goes to Diff Drivers
enables diff drivers and diff receivers
DEWAR DIFF DRIVERS
Second SPI connection
DO pair from ADC1
DO pair from ADC2
OD Buffer
Shutter not powered Shutter in closed position
Shutter powered Shutter in open position
TO-220 package with heatsink
Power's logic on board
reset means opening the shutter
set means closing the shutter
8V is distributed to ADC board
Overlap between this two pins?
LED INDICATORS
BIGGER, with heat sink?
TRIGGER
reevaluate size of resistor
Used a TIP102 on board
Reflex Circuit. Connect to 2PST
Connect to SPDT(MOM)(MOM) Switch

Board: 2 copper layers, 62 parts (0 on the bottom side), 67 nets, no tracks yet.

Other parts of the board:
BUFFER_OD1:04CAP, BUFFER_OD1:O5CAP: 100n; 0805_B
BUFFER_OD1:IC6: 74AC04D; SO14
BUFFER_OD1:IC7: 74ALS05D; SO14

Their connections:
5V: BUFFER_OD1:04CAP.2, BUFFER_OD1:IC6.14, BUFFER_OD1:IC7.14, BUFFER_OD1:O5CAP.2; also elsewhere on the board
BUFFER_OD1:N$1: BUFFER_OD1:IC6.2, BUFFER_OD1:IC7.1
BUFFER_OD1:N$2: BUFFER_OD1:IC6.10, BUFFER_OD1:IC7.11
BUFFER_OD1:N$3: BUFFER_OD1:IC6.12, BUFFER_OD1:IC7.13
BUFFER_OD1:N$36: BUFFER_OD1:IC6.4, BUFFER_OD1:IC7.3
BUFFER_OD1:N$37: BUFFER_OD1:IC6.6, BUFFER_OD1:IC7.5
BUFFER_OD1:N$38: BUFFER_OD1:IC6.8, BUFFER_OD1:IC7.9
CLOSE_PIN: BUFFER_OD1:IC6.5; also elsewhere on the board
DEWAR_FAULT_TRIGGER: BUFFER_OD1:IC6.1; also elsewhere on the board
GND: BUFFER_OD1:04CAP.1, BUFFER_OD1:IC6.7, BUFFER_OD1:IC7.7, BUFFER_OD1:O5CAP.1; also elsewhere on the board
OPEN_PIN: BUFFER_OD1:IC6.9; also elsewhere on the board
RESET_CLOSE_SHUTTER: BUFFER_OD1:IC7.2, BUFFER_OD1:IC7.4, BUFFER_OD1:IC7.6; also elsewhere on the board
SET_OPEN_SHUTTER: BUFFER_OD1:IC7.8; also elsewhere on the board
SHUTTER_FAULT_TRIGGER: BUFFER_OD1:IC6.3; also elsewhere on the board

File Shutter BOM.txt (part):

Partlist exported from /Users/eraticus/Library/Mobile Documents/com~apple~CloudDocs/Safety-Shutter-Circuit/Shutter.sch at 11/8/17 4:27 PM

Part                     Value                     Device                             Package                 Description                                   MF MPN         OC_FARNELL OC_NEWARK PROD_ID   
ADC1                     M08                       M08                                OSTVN08                                                                                                             
ADC1_FAULT               M03                       M03                                OSTVN03                                                                                                             
ADC2                     M08                       M08                                OSTVN08                                                                                                             
ADC2_FAULT               M03                       M03                                OSTVN03                                                                                                             
BUFFER_OD1:04CAP         100n                      CAP805B                            0805_B                                                                                                              
BUFFER_OD1:IC6           74AC04D                   74AC04D                            SO14                    Hex INVERTER                                                                                
BUFFER_OD1:IC7           74ALS05D                  74ALS05D                           SO14                    Hex INVERTER, open collector                                                                
BUFFER_OD1:O5CAP         100n                      CAP805B                            0805_B                                                                                                              
C1                       1u                        CAP5MM                             CAP_CER_TDK_FK28_5MM    Ceramic Capacitor                                                                           
C2                       1u                        CAP5MM                             CAP_CER_TDK_FK28_5MM    Ceramic Capacitor                                                                           
C3                       1u                        CAP5MM                             CAP_CER_TDK_FK28_5MM    Ceramic Capacitor                                                                           
C4                       1u                        CAP5MM                             CAP_CER_TDK_FK28_5MM    Ceramic Capacitor                                                                           
C5                       100n                      CAP805B                            0805_B                                                                                                              
C6                       100n                      CAP805B                            0805_B                                                                                                              
C7                       100n                      CAP805B                            0805_B                                                                                                              
C8                       100n                      CAP805B                            0805_B                                                                                                              
C9                       100n                      CAP805B                            0805_B                                                                                                              
C10                      100n                      CAP805B                            0805_B                                                                                                              
C11                      100n                      CAP805B                            0805_B                                                                                                              
C12                      100n                      CAP805B                            0805_B                                                                                                              
C13                      100n                      CAP805B                            0805_B                                                                                                              
C14                      100n                      CAP805B                            0805_B                                                                                                              
C15                      100n                      CAP805B                            0805_B                                                                                                              
C16                      1u                        CAP5MM                             CAP_CER_TDK_FK28_5MM    Ceramic Capacitor                                                                           
C17                      10u                       CAP_POL8_3.5                       CAP_POL_8_3.5           Polarized Capacitor, such as Electrolytic                                                   
C18                      1u                        CAP5MM                             CAP_CER_TDK_FK28_5MM    Ceramic Capacitor                                                                           
C19                      100n                      CAP805B                            0805_B                                                                                                              
CO[                      100n                      CAP805B                            0805_B                                                                                                              
D1                       AM26C31                   AM26C31                            SOIC_16_NARROW          Quadruple Differential Line Driver                                                          
D2                       AM26C31                   AM26C31                            SOIC_16_NARROW          Quadruple Differential Line Driver                                                          
D3                       1N4004                    1N4004                             DO41-10                 DIODE                                                                                       
DEWAR_SWITCH             M02                       M02                                OSTVN02                                                                                                             
IC3                      MAX3222                   MAX3222                            DIL18                   RS232 TRANSCEIVER                                MAX3222EPN+ 1188044    99K3237             
IC4                      74AC00D                   74AC00D                            SO14                    Quad 2-input NAND gate                                                                      
J1                       ATMEL_PROGRAMMER_HEADERTH ATMEL_PROGRAMMER_HEADERTH          ATMEL_PROGRAMMER_HEADER Board connector for Atmel MkII ISP programmer                                               
J2                                                 M06NO_SILK_FEMALE_PTH              1X06_NO_SILK            Header 6                                                                          CONN-08437
MC7808                   7808T                     7808T                              TO220H                  Positive VOLTAGE REGULATOR                                                                  
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
## EAGLE design ADC board 2.brd

Parts:
5V: TEST_POINT5015; 5015
!CS!: 0; 1206
AM26C31: AM26C31; SOIC_16_NARROW
AM26C32: AM26C32; SOIC_16_NARROW
AN_OUT: MO3; OSTVN03
C1, C3: 1u; 0805_B
C2, C4, C5, C8: 10u; 1206_A
C6, C7, C9, C10: 100n; 0805_B
G: TEST_POINT5015; 5015
GND: 0; 1206
IC1: 74AC08D; SO14
MCP3008: MCP3008MCP3008; SOIC-16-NARROW
R1, R2, R3: 100; 1206
REF4096: 4.096V; SOT23A(CB)
SENSOR_1, SENSOR_2, SENSOR_3, SENSOR_4: M05OSTVN05; OSTVN05
SPI: M08; OSTVN08
U$1: MIC29150; TO263-3
VIN: TEST_POINT5015; 5015
VREF: TEST_POINT5015; 5015

Connections:
4.096V: C4.2, MCP3008.15 (VREF), REF4096.2 (VOUT), VREF.1
5V: 5V.1, AM26C31.16 (VCC), AM26C32.2 (A), AM26C32.4 (G), AM26C32.16 (VCC), C2.2, C3.2, C5.2, C6.2, C7.2, C9.2, C10.2, IC1.14 (VCC), MCP3008.16 (VDD), REF4096.1 (VIN), U$1.3 (VOUT)
!CS!: !CS!.2, AM26C32.13 (Y), MCP3008.10 (!CS!)
!FAULT_1: IC1.1 (I0), SENSOR_1.5
!FAULT_2: IC1.2 (I1), SENSOR_2.5
!FAULT_3: IC1.4 (I0), SENSOR_3.5
!FAULT_4: IC1.5 (I1), SENSOR_4.5
!FAULT_OUT!: AN_OUT.1, IC1.8 (O)
CS+: AM26C32.14 (A), R3.2, SPI.7
CS-: AM26C32.15 (B), R3.1, SPI.8
DIN: AM26C32.11 (Y), MCP3008.11 (DIN)
DIN+: AM26C32.10 (A), R1.2, SPI.3
DIN-: AM26C32.9 (B), R1.1, SPI.4
DOUT: AM26C31.15 (A), MCP3008.12 (DOUT)
DOUT+: AM26C31.14 (Y), SPI.1
DOUT-: AM26C31.13 (Z), SPI.2
GND: AM26C31.1 (A), AM26C31.4 (G), AM26C31.7 (A), AM26C31.8 (GND), AM26C31.9 (A), AM26C32.1 (B), AM26C32.8 (GND), AM26C32.12 (!G!), AN_OUT.2, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, G.1, GND.2, IC1.7 (GND), IC1.12 (I0), IC1.13 (I1), MCP3008.9 (DGND), MCP3008.14 (AGND), REF4096.3 (GND), SENSOR_1.2, SENSOR_2.2, SENSOR_3.2, SENSOR_4.2, U$1.2 (GND), U$1.P$3 (GND)
unnamed: IC1.3 (O), IC1.10 (I1)
unnamed: IC1.6 (O), IC1.9 (I0)
SCK: AM26C32.5 (Y), MCP3008.13 (SCK)
SCK+: AM26C32.6 (A), R2.1, SPI.5
SCK-: AM26C32.7 (B), R2.2, SPI.6
SENSOR_1: MCP3008.1 (A0), SENSOR_1.3
SENSOR_2: MCP3008.3 (A2), SENSOR_2.3
SENSOR_3: MCP3008.5 (A4), SENSOR_3.3
SENSOR_4: MCP3008.7 (A6), SENSOR_4.3
THRESHOLD_1: MCP3008.2 (A1), SENSOR_1.4
THRESHOLD_2: MCP3008.4 (A3), SENSOR_2.4
THRESHOLD_3: MCP3008.6 (A5), SENSOR_3.4
THRESHOLD_4: MCP3008.8 (A7), SENSOR_4.4
TRANSMITTER_ENABLE: !CS!.1, AM26C31.12 (!G!), GND.1
VIN: AN_OUT.3, C1.2, C8.2, SENSOR_1.1, SENSOR_2.1, SENSOR_3.1, SENSOR_4.1, U$1.1 (VIN), VIN.1

Notes on the sheet:
HI if any of faults 1 though 4 are LOW
Power for 74AC00
TODO: Make parts for Differential tranmitter and reciever. Control transmitter with !CS! line.
To Sensor Boards
To Shutter Board
power entry on board
To Shutter Control
A choice of how to wire here
receivers are always on
necessary? OK to float inputs here?
Use M or Q rated parts.
get 2.5V reference also, if input voltages are low...
AGND and GND are connected

Board: 2 copper layers, 47.0 x 48.3 mm, 35 parts (0 on the bottom side), 32 nets.

Other parts of the board:
U$2, U$4, U$5, U$6: STAND-OFF

## EAGLE design Sensor Board v2.brd

Parts:
5V: TEST_POINT5015; 5015
C1: 22p; 0805_C
C2: 1u; 0805_C
C3, C4, C6, C7: 1u; 0805_B
C5: 10u; 1206_A
FLT: TEST_POINT5015; 5015
GND: TEST_POINT5015; 5015
MCP1702: MCP1702; SOT23A(CB)
MCP6001: MCP6001MCP6001; SOT23(OT)
MCP6541: MCP6541; SOT23(OT)
PHOTODIODE: VEMD6160X01
R1: 10M; 1206
SENSE: TEST_POINT5015; 5015
THRESH: TEST_POINT5015; 5015
TRIMPOT3224G: POTENTIOMETER; 3224G
U$1: M05OSTVN05; OSTVN05
U$2: PHOTODIODE; LTR-516AD
VIN: TEST_POINT5015; 5015

Connections:
5V: 5V.1, C3.2, C4.2, C6.2, MCP1702.2 (VOUT), MCP6001.5 (VDD), MCP6541.5 (VDD), TRIMPOT3224G.3 (CW)
FLUX_FAULT: FLT.1, MCP6541.1 (VOUT), U$1.4
GND: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, GND.1, MCP1702.1 (GND), MCP6001.2 (VSS), MCP6001.3 (VIN+), MCP6541.2 (VSS), PHOTODIODE.A1 (A), TRIMPOT3224G.1 (CCW), U$1.2, U$2.A
PHOTODIODE: C1.1, MCP6001.4 (VIN-), PHOTODIODE.K (C), R1.1, U$2.K (C)
SENSOR_OUT: C1.2, MCP6001.1 (VOUT), MCP6541.4 (VIN-), R1.2, SENSE.1, U$1.5
THRESHOLD: C7.2, MCP6541.3 (VIN+), THRESH.1, TRIMPOT3224G.2 (WIPER), U$1.3
VIN: C2.2, C5.2, MCP1702.3 (VIN), U$1.1, VIN.1

Notes on the sheet:
Put connector on
cap across power input
make 1206 footprint
Place SMD testpoint for Vin
Only one photodiode would be used at a time
Buy several resistor values
Should this be SMD?

Board: 2 copper layers, 34.3 x 19.1 mm, 25 parts (0 on the bottom side), 7 nets.

Other parts of the board:
U$3, U$4, U$5, U$6: STAND-OFF-TIGHT

## Commit log

2017-05-01 Minor changes to readme
2017-06-02 Sensor board that we are manufacturing via OSHPARK order number ucyGHMt4
2017-06-02 Sensor board that was sent for manufacture with OSHPARK order number ucyGHMt4
2017-06-02 ADC Boards that were sent for manufacture via OSHPARK order number Ufq3rBYH
2017-06-02 PDF versions of schematics for review outside of Eagle CAD
2017-06-02 more detailed description
2017-09-01 Adding software to git.
2017-09-01 Added .gitignore file and initial version of Shutter schematic
2017-09-14 Added two images which show/illusrate the wiring of the boards. Important for software developement and debugging.
2017-11-01 Commiting software for shutter
2017-11-02 Updates to schematic. Definitely not done yet!
2017-11-02 Software to run on ATMega328P programmed via Arduino IDE
2017-11-04 Update schematic to reflect current circuit. Change names of some nets to match sofware variables.
2017-11-04 Change some variables/constants to better match function on board.
2017-11-04 Adding board file. This file has not been worked on.
2017-11-04 Added board corresponding to Shutter.sch. This file has not been worked on yet.
2017-11-04 Remove Sensor Board.brd from repository. This was an old design which did NOT work.
2017-11-04 Added screw terminals for toggles.
2017-11-08 Add PDF version of ADC board schematic.
2017-11-09 Added Shutter circuit schematic.
2017-11-09 Digikey Bills of Material for the ADC Circuit and the Diode Circuit.
2017-11-09 Add BOM for Shutter
2017-11-17 Changed feedback resistor value to match currently used on board.
2017-11-17 Added descriptions to BOM
2017-11-17 Added OD buffer schematic to complete Shutter Circuit Schematic.

Notices in the files:
parts and their libraries:
SparkFun-Electromechanical: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
